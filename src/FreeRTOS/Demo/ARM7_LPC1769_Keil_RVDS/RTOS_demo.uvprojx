# Keil uVision project RTOS_demo.uvprojx, settings and files
target FILES (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOS_demo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Source\include;..\ARM7_LPC1769_Keil_RVDS;..\..\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group FREE_RTOS
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
  group PROJET
    ./: main.c myTasks.c images_data.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
